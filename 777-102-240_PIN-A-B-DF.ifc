Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: 2018_01
Time: 2024-01-15T14:15:03+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.20.21 - Exporter 23.0.20.21 - Default UI

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingElementProxy: Familie1:Norm, Familie1:Norm:2420176
In: Default
Type - Material: <Unnamed>
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - ID-Daten - Typname: Norm
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Familie1
Pset_BuildingElementProxyCommon - Reference: Norm; sets with these values: 2
Abhängigkeiten - Basisbauteil: Keine; Höhe von Ebene: 0 m; Versatz von Host: 0 m; Verschieben mit umliegenden Elementen: no
Bemaßungen - Fläche: 0.12168 m2; Volumen: 0.0013402 m3
Phasen - Phase erstellt: Phase 2
Sonstige - Familie: Familie1; Familie und Typ: Familie1: Norm; Typ: Norm; Typ-ID: 2420161
